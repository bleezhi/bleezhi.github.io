options:
  parameters:
    author: bleez
    description: bleeFM 103.7 FM with RDS. ALSA Loopback hw:3,1 -> FM multiplex -> TCP IQ for SimTx.
    generate_options: qt_gui
    id: bleefm_1037_rds
    output_language: python
    title: bleeFM 103.7 FM + RDS
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: mpx_rate
  id: variable
  parameters:
    value: '380000'
  states: {}
- name: iq_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: fm_deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: rds_gain
  id: variable
  parameters:
    value: '0.05'
  states: {}
- name: audio_gain
  id: variable
  parameters:
    value: '0.85'
  states: {}
- name: tcp_host
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '7355'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '''hw:3,1'''
    samp_rate: audio_rate
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    comment: 50 us preemphasis for European FM broadcast
    fh: '-1.0'
    samp_rate: audio_rate
    tau: '50e-6'
  states: {}
- name: rational_resampler_audio
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '95'
    taps: ''
    type: fff
  states: {}
- name: blocks_multiply_const_audio
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 103.7e6
    max_latency: '104'
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '0'
    pi_reference_number: '1'
    ps: BLEEZ FM
    pty: '10'
    pty_locale: '0'
    radiotext: bleeFM 103.7 MHz
    ta: 'False'
    tp: 'False'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,2]'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '160'
    gain: '111'
    interp: '160'
    ntaps: 160*11
    samp_rate: mpx_rate
    sym_rate: '2375'
    type: interp_fir_filter_fff
  states: {}
- name: analog_sig_source_rds_carrier
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '57000'
    offset: '0'
    phase: '0'
    samp_rate: mpx_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_rds_carrier
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_rds
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_rds
  id: blocks_multiply_const_vxx
  parameters:
    const: rds_gain
    type: float
  states: {}
- name: blocks_add_mpx
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: 75 kHz broadcast FM deviation
    sensitivity: 2*math.pi*fm_deviation/mpx_rate
  states: {}
- name: rational_resampler_iq
  id: rational_resampler_xxx
  parameters:
    decim: '95'
    interp: '48'
    taps: ''
    type: ccc
  states: {}
- name: blocks_tcp_sink_0
  id: blocks_tcp_sink
  parameters:
    addr: tcp_host
    port: tcp_port
    server: 'True'
    type: complex
  states: {}

connections:
- [audio_source_0, '0', analog_fm_preemph_0, '0']
- [analog_fm_preemph_0, '0', rational_resampler_audio, '0']
- [rational_resampler_audio, '0', blocks_multiply_const_audio, '0']
- [blocks_multiply_const_audio, '0', blocks_add_mpx, '0']
- [rds_encoder_0, '0', digital_diff_encoder_bb_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_rds, '0']
- [analog_sig_source_rds_carrier, '0', blocks_complex_to_real_rds_carrier, '0']
- [blocks_complex_to_real_rds_carrier, '0', blocks_multiply_rds, '1']
- [blocks_multiply_rds, '0', blocks_multiply_const_rds, '0']
- [blocks_multiply_const_rds, '0', blocks_add_mpx, '1']
- [blocks_add_mpx, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', rational_resampler_iq, '0']
- [rational_resampler_iq, '0', blocks_tcp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
