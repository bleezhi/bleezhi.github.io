options:
  parameters:
    author: bleez
    description: 'bleeFM 103.7 FM transmitter: ALSA loopback -> WBFM -> TCP IQ for SimTx'
    generate_options: qt_gui
    id: bleefm_1037
    output_language: python
    run_command: '{filename}.py'
    title: bleeFM 103.7 FM transmitter
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: tcp_host
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: tcp_port
  id: variable
  parameters:
    value: '7355'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '''hw:3,1'''
    num_inputs: '1'
    sample_rate: audio_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '0.0'
    max_dev: max_dev
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: blocks_tcp_sink_0
  id: blocks_tcp_sink
  parameters:
    addr: tcp_host
    port: tcp_port
    server: 'True'
    type: complex
  states: {}

connections:
- [audio_source_0, '0', analog_wfm_tx_0, '0']
- [analog_wfm_tx_0, '0', blocks_tcp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0
