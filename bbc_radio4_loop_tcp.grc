options:
  parameters:
    author: bleez
    description: Loop BBC Radio 4 audio and stream PCM samples over TCP.
    id: bbc_radio4_loop_tcp
    output_language: python
    title: BBC Radio 4 loop -> TCP
  states: {}

blocks:
- name: audio_file
  id: blocks_wavfile_source
  parameters:
    file: /home/bleez/Downloads/BBC Radio 4 Longwave Shutdown message on repeat via Kenwood TS-890S.mp3
    format: float
    repeat: 'True'
    type: float
  states: {}
- name: tcp_sink
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    eof: 'False'
    port: '5000'
    server: 'True'
    type: float
  states: {}

connections:
- [audio_file, '0', tcp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.0
